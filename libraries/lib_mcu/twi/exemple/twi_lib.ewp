# IAR project twi_lib.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  ICCAVR.newCCIncludePaths: ..\..\..\; 
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: lnkm128s.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
  group Common sources
    ./: main.c
    ../../../../../../../../../users/jean_se/work/c51/lib_mcu/twi/: twi_lib.c
